<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HC-SRO4.ewp</path>
  </project>
  <batchBuild />
</workspace>
